# Keil uVision project LoadBox.uvprojx, settings and files
target LoadBox (ARM-ADS)
  device: STM32F030RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LoadBox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: .\CMSIS;.\Headers;.\Libraries\inc;.\Libraries\src;.\Startup;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ./Libraries/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ./CMSIS/: stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group Startup
    ./Startup/: startup_stm32f030xc.s
  group Headers
    ./Headers/: gpio_app.h gpio_driver.h key_logic.h main.h stm32f0xx_conf.h stm32f0xx_it.h uart_app.h uart_driver.h public.h i2c_app.h i2c_driver.h
  group Drivers
    ./User/Drivers/: gpio_driver.c uart_driver.c i2c_driver.c
  group DriverApp
    ./User/DriverApp/: gpio_app.c uart_app.c i2c_app.c
  group User
    ./User/: key_logic.c main.c stm32f0xx_it.c public.c
